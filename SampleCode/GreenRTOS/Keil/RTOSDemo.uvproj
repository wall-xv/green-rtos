# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_ARM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c include: ..\;..\..\..\ThirdParty\GreenRTOS;..\..\..\Driver\Include;..\portable\RVDS\ARM9_NUC970\
  asm include: ..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Source\portable\RVDS\ARM9_NUC970
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc970.sct
  link misc: --entry 0
  group Startup
    ../: main.c
    ./Startup/: startup.s
    ../../../Driver/Source/: standalone.c
  group Lib
    ../../../Driver/Source/: sys.c sys_uart.c system_nuc970.c sys_nuc970.s etimer.c
  group GreenRTOS
    ../../../ThirdParty/GreenRTOS/: grtos.h grtos_mm.c grtos_mutex.c grtos_sem.c grtos_task.c grtos_time.c grtos_trace.c m_list.h m_type.h
  group Port
    ../portable/RVDS/ARM9_NUC970/: port.c portASM.s portmacro.h portmacro.inc
